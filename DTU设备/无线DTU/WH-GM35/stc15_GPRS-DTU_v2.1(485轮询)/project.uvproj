# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: dtu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\stclib;..\stc_lib;.\app;.\app\service\app;.\app\service\AES128;.\app\service\CRC16;.\app\service\GPRS;.\app\service\cjsion;.\app\service\print
  group app
    ./: config.h
    ./app/: main.c sys_clock.c mystring.c
    ./app/service/app/: function.c
    ./app/service/AES128/: aes128app.c aes.c
    ./app/service/CRC16/: crc16.c
    ./app/service/GPRS/: GPRS.c
    ./app/service/print/: print.c
  group stclib
    ./stclib/: delay.c GPIO.c USART1.C stc_timer.c eeprom.c
